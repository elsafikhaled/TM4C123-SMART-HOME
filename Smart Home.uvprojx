# Keil uVision project Smart Home.uvprojx, settings and files
target Application (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Smart Home
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source files
    ./: Delay.c GPIO.c lcdEKE.c Sound.c SysCtrl.c data_types.h Delay.h GPIO.h HW_gpio.h lcdEKE.h Sound.h SysCtrl.h main.c startup_TM4C123.s
